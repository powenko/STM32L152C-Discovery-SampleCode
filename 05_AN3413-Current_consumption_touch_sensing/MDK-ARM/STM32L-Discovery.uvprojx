# Keil uVision project STM32L-Discovery.uvprojx, settings and files
target STM32L152RC (32L152C-DISCOVERY) (ARM-ADS)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L-Discovery +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MDP, TSLPRM_STM32L1XX_SW_ACQ
  c include: ..\inc;..\..\..\libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Libraries\STMTouch_Driver\inc;..\..\..\Utilities\STM32L-DISCOVERY;..\..\..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x7c00
  memory RVCT10: RAM 0x20007c00 size 0x400
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_syscfg.c misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c
  group User
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
    ../src/: stm32l1xx_it.c main.c icc_measure_Ram.c icc_measure.c discover_functions.c system_stm32l1xx.c tsl_user.c
  group DOC
    ../: Readme.txt
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
  group STMTouch_Driver
    ../../../Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_acq_stm32l1xx_sw.c
target STM32L152RB (STM32L-DISCOVERY) (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L-Discovery +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, TSLPRM_STM32L1XX_SW_ACQ
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
